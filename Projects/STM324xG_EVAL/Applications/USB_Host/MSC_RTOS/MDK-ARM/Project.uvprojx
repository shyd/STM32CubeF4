# Keil uVision project Project.uvprojx, settings and files
target STM324xG-EVAL_USBH-FS (ARM-ADS)
  device: STM32F407IGHx STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324xG-EVAL_USBH-FS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STM324xG_EVAL,USE_USB_FS
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/Include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Drivers/BSP/STM324xG_EVAL;../../../../../../Utilities/Log
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c lcd_log.c
  group Drivers/BSP/STM324xG_EVAL
    ../../../../../../Drivers/BSP/STM324xG_EVAL/: stm324xg_eval_lcd.c stm324xg_eval_io.c stm324xg_eval.c stm324xg_eval_lcd.c stm324xg_eval_io.c stm324xg_eval.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c stmpe811.c
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c ili9325.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c port.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c system_stm32f4xx.c
  group Doc
    ../: readme.txt readme.txt
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s startup_stm32f407xx.s
  group Application/User
    ../Src/: usbh_conf.c stm32f4xx_it.c usbh_diskio.c menu.c main.c file_operations.c explorer.c stm32f4xx_hal_timebase_tim.c usbh_conf.c stm32f4xx_it.c usbh_diskio.c menu.c main.c file_operations.c explorer.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_sram.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_sram.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_cortex.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c timers.c tasks.c croutine.c list.c queue.c timers.c tasks.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_pipes.c usbh_ctlreq.c usbh_core.c usbh_ioreq.c usbh_pipes.c usbh_ctlreq.c usbh_core.c usbh_ioreq.c
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff.c ff.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_bot.c usbh_msc.c usbh_msc_scsi.c usbh_msc_bot.c usbh_msc.c usbh_msc_scsi.c
target STM324xG-EVAL_USBH-HS (ARM-ADS)
  device: STM32F407IGHx STMicroelectronics
  cpu: as above
  output: STM324xG-EVAL_USBH-HS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STM324xG_EVAL,USE_USB_HS
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Drivers/BSP/STM324xG_EVAL;../../../../../../Utilities/Log
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 4.3.0
