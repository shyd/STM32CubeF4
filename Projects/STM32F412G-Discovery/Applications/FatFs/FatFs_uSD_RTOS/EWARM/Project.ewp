# IAR project Project.ewp, settings and files
configuration STM32412G_DISCOVERY (ARM, debug)
  General.OGChipSelectEditMenu: STM32F412ZG ST STM32F412ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F412Zx; USE_HAL_DRIVER; USE_STM32412G_DISCOVERY
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32412G-Discovery; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Utilities\Log; ..\..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: STM32F412ZG_DISCOVERY.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f412zx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f412zx.s
  group Application/User
    ../Src/: main.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32412G-Discovery
    ../../../../../../Drivers/BSP/STM32412G-Discovery/: stm32412g_discovery.c stm32412g_discovery_sd.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/FatFs/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
