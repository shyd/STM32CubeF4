# IAR project Project.ewp, settings and files
configuration STM32F413H_DISCOVERY (ARM, debug)
  General.OGChipSelectEditMenu: STM32F413ZH ST STM32F413ZH
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F413xx; USE_HAL_DRIVER; USE_STM32F413H_DISCOVERY
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F413H-Discovery; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Utilities\Log; ..\..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\..\Utilities; ..\..\..\..\..\..\Utilities\fonts; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f413xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f413xx.s
  group Application/User
    ../Src/: fatfs_storage.c main.c stm32f4xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
  group Drivers/BSP/STM32F413H-Discovery
    ../../../../../../Drivers/BSP/STM32F413H-Discovery/: stm32f413h_discovery.c stm32f413h_discovery_lcd.c stm32f413h_discovery_sd.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sram.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
